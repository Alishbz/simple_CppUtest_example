# IAR project test_project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 52
  General.FPU2: 5
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: Debug; cpputest-3.8\src\CppUTest; cpputest-3.8\include\CppUTest; $PROJ_DIR$; cpputest-3.8\src\Platforms\Iar; cpputest-3.8\src; cpputest-3.8\include; Test_Project\Test; cpputest-3.8\include\CppUTestExt; cpputest-3.8\src\CppUTestExt; Test_Project\Project\queue; Test_Project\Project\led_driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\Users\SAYKAL\Desktop\iar_cpputest\test_project.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.cpp
  group cpputest_include
    cpputest-3.8/include/CppUTest/: CommandLineArguments.h CommandLineTestRunner.h CppUTestConfig.h CppUTestGeneratedConfig.h JUnitTestOutput.h MemoryLeakDetector.h MemoryLeakDetectorMallocMacros.h MemoryLeakDetectorNewMacros.h MemoryLeakWarningPlugin.h PlatformSpecificFunctions.h PlatformSpecificFunctions_c.h SimpleMutex.h SimpleString.h StandardCLibrary.h TeamCityTestOutput.h TestFailure.h TestFilter.h TestHarness.h TestHarness_c.h TestMemoryAllocator.h TestOutput.h TestPlugin.h TestRegistry.h TestResult.h TestTestingFixture.h Utest.h UtestMacros.h
  group cpputest_mock_include
    cpputest-3.8/include/CppUTestExt/: CodeMemoryReportFormatter.h GMock.h GTest.h GTestConvertor.h IEEE754ExceptionsPlugin.h MemoryReportAllocator.h MemoryReporterPlugin.h MemoryReportFormatter.h MockActualCall.h MockCheckedActualCall.h MockCheckedExpectedCall.h MockExpectedCall.h MockExpectedCallsList.h MockFailure.h MockNamedValue.h MockSupport.h MockSupport_c.h MockSupportPlugin.h OrderedTest.h
  group cpputest_mock_src
    cpputest-3.8/src/CppUTestExt/: CodeMemoryReportFormatter.cpp IEEE754ExceptionsPlugin.cpp MemoryReportAllocator.cpp MemoryReporterPlugin.cpp MemoryReportFormatter.cpp MockActualCall.cpp MockExpectedCall.cpp MockExpectedCallsList.cpp MockFailure.cpp MockNamedValue.cpp MockSupport.cpp MockSupport_c.cpp MockSupportPlugin.cpp OrderedTest.cpp
  group cpputest_src
    cpputest-3.8/src/CppUTest/: CommandLineArguments.cpp CommandLineTestRunner.cpp JUnitTestOutput.cpp MemoryLeakDetector.cpp MemoryLeakWarningPlugin.cpp SimpleMutex.cpp SimpleString.cpp TeamCityTestOutput.cpp TestFailure.cpp TestFilter.cpp TestHarness_c.cpp TestMemoryAllocator.cpp TestOutput.cpp TestPlugin.cpp TestRegistry.cpp TestResult.cpp TestTestingFixture.cpp Utest.cpp
  group platforms
    cpputest-3.8/src/Platforms/Iar/: UtestPlatform.cpp
  group Work_Space/Project/led_driver
    Test_Project/Project/led_driver/: led_driver.c led_driver.h
  group Work_Space/Project/queue
    Test_Project/Project/queue/: queue.c queue.h
  group Work_Space/Testers
    Test_Project/Test/: led_driver_test.cpp queue_test.cpp
